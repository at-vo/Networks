# Keil uVision project asn5.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: asn5
  c flags: Optim=1
  group Source Group 1
    ../lab7/: Assembly_Lab_7_Source.s
