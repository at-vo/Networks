# Keil uVision project lab6.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: lab6
  c flags: Optim=1
  group Source Group 1
    ./: Assembly_Lab_6_Q2_Source.s
