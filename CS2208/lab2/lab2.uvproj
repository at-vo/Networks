# Keil uVision project lab2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: lab2
  c flags: Optim=1
  group Source Group 1
    ./: More_data_definitions.s
