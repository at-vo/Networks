#include <stdio.h>

const char segments[10][3][3] = {
    // top            // mid            // bot
    {{' ', '_', ' '}, {'|', ' ', '|'}, {'|', '_', '|'}}, // 0
    {{' ', ' ', ' '}, {' ', ' ', '|'}, {' ', ' ', '|'}}, // 1
    {{' ', '_', ' '}, {' ', '_', '|'}, {'|', '_', ' '}}, // 2
    {{' ', '_', ' '}, {' ', '_', '|'}, {' ', '_', '|'}}, // 3
    {{' ', ' ', ' '}, {'|', '_', '|'}, {' ', ' ', '|'}}, // 4
    {{' ', '_', ' '}, {'|', '_', ' '}, {' ', '_', '|'}}, // 5
    {{' ', '_', ' '}, {'|', '_', ' '}, {'|', '_', '|'}}, // 6
    {{' ', '_', ' '}, {' ', ' ', '|'}, {' ', ' ', '|'}}, // 7
    {{' ', '_', ' '}, {'|', '_', '|'}, {'|', '_', '|'}}, // 8
    {{' ', '_', ' '}, {'|', '_', '|'}, {' ', '_', '|'}}  // 9
};


int main()
{
    char nums[12];
    int get; // gets the inputted value
    printf("enter input: ");
    scanf("%d", &get);
    sprintf(nums, "%d", get); // places in valu
    int count = 0;

    while (nums[count] != '\0')
    {
        count++;
    }

    for (int i = 0; i < 3; i++)
    {
        for (int j = 0; j < count; j++)
        {
            if (get < 0)
                {
                    if (j == 0 && i != 1)
                    {
                        printf(" ");
                    }
                    else if (j == 0 && i == 1)
                    {
                        printf("_");
                    }
                }
            for (int k = 0; k < 3; k++)
            {
                
                printf("%c", segments[nums[j] - '0'][i][k]);
            }
        }
        printf("\n");
    }

    return 0;
}
